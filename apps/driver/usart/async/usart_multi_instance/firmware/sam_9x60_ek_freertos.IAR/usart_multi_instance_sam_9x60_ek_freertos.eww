<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\usart_multi_instance_sam_9x60_ek_freertos.ewp</path>
    </project>
    <batchBuild />
</workspace>
