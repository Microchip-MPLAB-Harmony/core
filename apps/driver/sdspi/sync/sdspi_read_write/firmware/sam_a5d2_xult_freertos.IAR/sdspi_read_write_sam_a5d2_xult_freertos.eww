<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\sdspi_read_write_sam_a5d2_xult_freertos.ewp</path>
    </project>
</workspace>
