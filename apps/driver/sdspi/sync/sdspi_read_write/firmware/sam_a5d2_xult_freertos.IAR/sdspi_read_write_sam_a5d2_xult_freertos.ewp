# IAR project sdspi_read_write_sam_a5d2_xult_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Microchip ATSAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCIncludePath2: ..\..\firmware\src; ..\..\firmware\src\config\sam_a5d2_xult_freertos; ..\..\firmware\src\packs\ATSAMA5D27_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core_A\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm; ..\..\firmware\src\third_party\rtos\FreeRTOS\Source\portable\IAR\SAM\CA5; ..\..\firmware\src\third_party\rtos\FreeRTOS\Source\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: sdspi_read_write_sam_a5d2_xult_freertos.out
  ILINK.IlinkIcfFile: ..\..\firmware\src\config\sam_a5d2_xult_freertos\ddr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/config/sam_a5d2_xult_freertos/: sam_a5d2_xult_freertos.ipcf
  group IAR Project Connection File/Header Files
    ../src/packs/ATSAMA5D27_DFP/component/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom.h gmac.h i2sc.h icm.h isc.h l2cc.h lcdc.h matrix.h mcan.h mpddrc.h pdmic.h pio.h pio_ctrl.h pit.h pmc.h ptc.h pwm.h qspi.h rstc.h rtc.h rxlp.h sckc.h sdmmc.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi.h ssc.h tc.h tdes.h trng.h twihs.h uart.h udphs.h uhphs.h wdt.h xdmac.h
    ../src/: app.h
    ../src/packs/ATSAMA5D27_DFP/: atsama5d27.h device.h
    ../src/config/sam_a5d2_xult_freertos/bsp/: bsp.h
    ../src/packs/CMSIS/CMSIS/Core_A/Include/: cmsis_compiler.h cmsis_cp15.h cmsis_gcc.h cmsis_iccarm.h core_ca.h
    ../src/config/sam_a5d2_xult_freertos/: configuration.h definitions.h device_cache.h FreeRTOSConfig.h toolchain_specifics.h user.h
    ../src/third_party/rtos/FreeRTOS/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
    ../src/config/sam_a5d2_xult_freertos/driver/: driver.h driver_common.h
    ../src/config/sam_a5d2_xult_freertos/driver/sdspi/: drv_sdspi.h drv_sdspi_definitions.h
    ../src/config/sam_a5d2_xult_freertos/driver/sdspi/src/: drv_sdspi_local.h drv_sdspi_plib_interface.h
    ../src/config/sam_a5d2_xult_freertos/osal/: osal.h osal_definitions.h osal_freertos.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/aic/: plib_aic.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/clk/: plib_clk.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/l2cc/: plib_l2cc.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/matrix/: plib_matrix.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/mmu/: plib_mmu.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/pio/: plib_pio.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/pit/: plib_pit.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/spi/: plib_spi1.h plib_spi_common.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/tc/: plib_tc0.h plib_tc_common.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/xdmac/: plib_xdmac0.h plib_xdmac_common.h
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/CA5/: portASM.h portmacro.h
    ../src/packs/ATSAMA5D27_DFP/pio/: sama5d27.h
    ../src/config/sam_a5d2_xult_freertos/system/cache/: sys_cache.h
    ../src/config/sam_a5d2_xult_freertos/system/dma/: sys_dma.h sys_dma_mapping.h
    ../src/config/sam_a5d2_xult_freertos/system/int/: sys_int.h sys_int_mapping.h
    ../src/config/sam_a5d2_xult_freertos/system/ports/: sys_ports.h sys_ports_mapping.h
    ../src/config/sam_a5d2_xult_freertos/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_a5d2_xult_freertos/system/time/src/: sys_time_local.h
    ../src/config/sam_a5d2_xult_freertos/system/: system.h system_common.h system_media.h system_module.h
  group IAR Project Connection File/Source Files
    ../src/: app.c main.c
    ../src/config/sam_a5d2_xult_freertos/bsp/: bsp.c
    ../src/third_party/rtos/FreeRTOS/Source/: croutine.c event_groups.c FreeRTOS_tasks.c list.c queue.c stream_buffer.c timers.c
    ../src/config/sam_a5d2_xult_freertos/: cstartup.s fault_handlers.c freertos_hooks.c initialization.c interrupts.c tasks.c
    ../src/config/sam_a5d2_xult_freertos/driver/sdspi/src/: drv_sdspi.c drv_sdspi_plib_interface.c
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/CA5/: FreeRTOS_tick_config.c port.c portASM.s
    ../src/third_party/rtos/FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../src/config/sam_a5d2_xult_freertos/stdio/: iar_monitor.c
    ../src/config/sam_a5d2_xult_freertos/osal/: osal_freertos.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/aic/: plib_aic.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/clk/: plib_clk.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/l2cc/: plib_l2cc.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/matrix/: plib_matrix.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/mmu/: plib_mmu.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/pio/: plib_pio.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/pit/: plib_pit.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/spi/: plib_spi1.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/tc/: plib_tc0.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/xdmac/: plib_xdmac0.c
    ../src/config/sam_a5d2_xult_freertos/system/cache/: sys_cache.c
    ../src/config/sam_a5d2_xult_freertos/system/dma/: sys_dma.c
    ../src/config/sam_a5d2_xult_freertos/system/int/src/: sys_int.c
    ../src/config/sam_a5d2_xult_freertos/system/time/src/: sys_time.c
