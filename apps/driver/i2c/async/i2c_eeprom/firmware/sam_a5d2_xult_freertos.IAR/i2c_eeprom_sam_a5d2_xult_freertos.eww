<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\i2c_eeprom_sam_a5d2_xult_freertos.ewp</path>
    </project>
    <batchBuild />
</workspace>
