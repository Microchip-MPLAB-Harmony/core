<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\spi_multi_slave_sam_9x60_ek.ewp</path>
    </project>
</workspace>
