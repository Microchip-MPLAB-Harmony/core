# IAR project spi_multi_slave_sam_9x60_ek_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM9X60 Microchip SAM9X60
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\firmware\src; ..\..\firmware\src\config\sam_9x60_ek_freertos; ..\..\firmware\src\packs\SAM9X60_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm; ..\..\firmware\src\third_party\rtos\FreeRTOS\Source\portable\IAR\SAM\ARM926; ..\..\firmware\src\third_party\rtos\FreeRTOS\Source\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: spi_multi_slave_sam_9x60_ek_freertos.out
  ILINK.IlinkIcfFile: ..\..\firmware\src\config\sam_9x60_ek_freertos\ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/config/sam_9x60_ek_freertos/: sam_9x60_ek_freertos.ipcf
  group IAR Project Connection File/Header Files
    ../src/packs/SAM9X60_DFP/component/: adc.h aes.h aic.h bsc.h can.h classd.h dbgu.h emac.h flexcom.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pio.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc.h tdes.h trng.h udphs.h uhpfs.h uhphs.h wdt.h xdmac.h
    ../src/: app_eeprom1.h app_eeprom2.h app_monitor.h
    ../src/config/sam_9x60_ek_freertos/bsp/: bsp.h
    ../src/config/sam_9x60_ek_freertos/: configuration.h definitions.h device_cache.h FreeRTOSConfig.h toolchain_specifics.h user.h
    ../src/config/sam_9x60_ek_freertos/peripheral/mmu/: cp15.h plib_mmu.h
    ../src/third_party/rtos/FreeRTOS/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
    ../src/packs/SAM9X60_DFP/: device.h sam9x60.h
    ../src/config/sam_9x60_ek_freertos/driver/: driver.h driver_common.h
    ../src/config/sam_9x60_ek_freertos/driver/spi/: drv_spi.h drv_spi_definitions.h
    ../src/config/sam_9x60_ek_freertos/osal/: osal.h osal_definitions.h osal_freertos.h
    ../src/config/sam_9x60_ek_freertos/peripheral/aic/: plib_aic.h
    ../src/config/sam_9x60_ek_freertos/peripheral/clk/: plib_clk.h
    ../src/config/sam_9x60_ek_freertos/peripheral/flexcom/spi/: plib_flexcom4_spi.h plib_flexcom_spi_local.h
    ../src/config/sam_9x60_ek_freertos/peripheral/pio/: plib_pio.h
    ../src/config/sam_9x60_ek_freertos/peripheral/pit/: plib_pit.h
    ../src/config/sam_9x60_ek_freertos/peripheral/xdmac/: plib_xdmac.h plib_xdmac_common.h
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/ARM926/: portmacro.h
    ../src/packs/SAM9X60_DFP/pio/: sam9x60.h
    ../src/config/sam_9x60_ek_freertos/system/cache/: sys_cache.h
    ../src/config/sam_9x60_ek_freertos/system/dma/: sys_dma.h sys_dma_mapping.h
    ../src/config/sam_9x60_ek_freertos/system/int/: sys_int.h sys_int_mapping.h
    ../src/config/sam_9x60_ek_freertos/system/ports/: sys_ports.h sys_ports_mapping.h
    ../src/config/sam_9x60_ek_freertos/system/: system.h system_common.h system_module.h
  group IAR Project Connection File/Source Files
    ../src/: app_eeprom1.c app_eeprom2.c app_monitor.c main.c
    ../src/config/sam_9x60_ek_freertos/bsp/: bsp.c
    ../src/third_party/rtos/FreeRTOS/Source/: croutine.c event_groups.c FreeRTOS_tasks.c list.c queue.c stream_buffer.c timers.c
    ../src/config/sam_9x60_ek_freertos/: cstartup.s exceptions.c freertos_hooks.c initialization.c interrupts.c tasks.c vectortrap.s
    ../src/config/sam_9x60_ek_freertos/driver/spi/src/: drv_spi.c drv_spi_local.h
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/ARM926/: FreeRTOS_tick_config.c port.c portASM.s
    ../src/third_party/rtos/FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../src/config/sam_9x60_ek_freertos/stdio/: iar_monitor.c
    ../src/config/sam_9x60_ek_freertos/osal/: osal_freertos.c
    ../src/config/sam_9x60_ek_freertos/peripheral/aic/: plib_aic.c
    ../src/config/sam_9x60_ek_freertos/peripheral/clk/: plib_clk.c
    ../src/config/sam_9x60_ek_freertos/peripheral/flexcom/spi/: plib_flexcom4_spi.c
    ../src/config/sam_9x60_ek_freertos/peripheral/mmu/: plib_mmu.c
    ../src/config/sam_9x60_ek_freertos/peripheral/pio/: plib_pio.c
    ../src/config/sam_9x60_ek_freertos/peripheral/pit/: plib_pit.c
    ../src/config/sam_9x60_ek_freertos/peripheral/xdmac/: plib_xdmac.c
    ../src/config/sam_9x60_ek_freertos/system/cache/: sys_cache.c
    ../src/config/sam_9x60_ek_freertos/system/dma/: sys_dma.c
    ../src/config/sam_9x60_ek_freertos/system/int/src/: sys_int.c
