# IAR project spi_multi_slave_sam_a5d2_xult.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Microchip ATSAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCIncludePath2: ..\..\firmware\src; ..\..\firmware\src\config\sam_a5d2_xult; ..\..\firmware\src\packs\ATSAMA5D27_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core_A\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: spi_multi_slave_sam_a5d2_xult.out
  ILINK.IlinkIcfFile: ..\..\firmware\src\config\sam_a5d2_xult\ddr.icf
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/config/sam_a5d2_xult/: sam_a5d2_xult.ipcf
  group IAR Project Connection File/Header Files
    ../src/packs/ATSAMA5D27_DFP/component/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom.h gmac.h i2sc.h icm.h isc.h l2cc.h lcdc.h matrix.h mcan.h mpddrc.h pdmic.h pio.h pio_ctrl.h pit.h pmc.h ptc.h pwm.h qspi.h rstc.h rtc.h rxlp.h sckc.h sdmmc.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi.h ssc.h tc.h tdes.h trng.h twihs.h uart.h udphs.h uhphs.h wdt.h xdmac.h
    ../src/: app_eeprom1.h app_eeprom2.h app_monitor.h
    ../src/packs/ATSAMA5D27_DFP/: atsama5d27.h device.h
    ../src/config/sam_a5d2_xult/bsp/: bsp.h
    ../src/packs/CMSIS/CMSIS/Core_A/Include/: cmsis_compiler.h cmsis_cp15.h cmsis_gcc.h cmsis_iccarm.h core_ca.h
    ../src/config/sam_a5d2_xult/: configuration.h definitions.h device_cache.h toolchain_specifics.h user.h
    ../src/config/sam_a5d2_xult/driver/: driver.h driver_common.h
    ../src/config/sam_a5d2_xult/driver/spi/: drv_spi.h drv_spi_definitions.h
    ../src/config/sam_a5d2_xult/osal/: osal.h osal_definitions.h osal_impl_basic.h
    ../src/config/sam_a5d2_xult/peripheral/aic/: plib_aic.h
    ../src/config/sam_a5d2_xult/peripheral/clk/: plib_clk.h
    ../src/config/sam_a5d2_xult/peripheral/l2cc/: plib_l2cc.h
    ../src/config/sam_a5d2_xult/peripheral/matrix/: plib_matrix.h
    ../src/config/sam_a5d2_xult/peripheral/mmu/: plib_mmu.h
    ../src/config/sam_a5d2_xult/peripheral/pio/: plib_pio.h
    ../src/config/sam_a5d2_xult/peripheral/pit/: plib_pit.h
    ../src/config/sam_a5d2_xult/peripheral/spi/: plib_spi1.h plib_spi_common.h
    ../src/packs/ATSAMA5D27_DFP/pio/: sama5d27.h
    ../src/config/sam_a5d2_xult/system/cache/: sys_cache.h
    ../src/config/sam_a5d2_xult/system/dma/: sys_dma.h sys_dma_mapping.h
    ../src/config/sam_a5d2_xult/system/int/: sys_int.h sys_int_mapping.h
    ../src/config/sam_a5d2_xult/system/ports/: sys_ports.h sys_ports_mapping.h
    ../src/config/sam_a5d2_xult/system/: system.h system_common.h system_module.h
  group IAR Project Connection File/Source Files
    ../src/: app_eeprom1.c app_eeprom2.c app_monitor.c main.c
    ../src/config/sam_a5d2_xult/bsp/: bsp.c
    ../src/config/sam_a5d2_xult/: cstartup.s fault_handlers.c initialization.c interrupts.c tasks.c
    ../src/config/sam_a5d2_xult/driver/spi/src/: drv_spi.c drv_spi_local.h
    ../src/config/sam_a5d2_xult/stdio/: iar_monitor.c
    ../src/config/sam_a5d2_xult/peripheral/aic/: plib_aic.c
    ../src/config/sam_a5d2_xult/peripheral/clk/: plib_clk.c
    ../src/config/sam_a5d2_xult/peripheral/l2cc/: plib_l2cc.c
    ../src/config/sam_a5d2_xult/peripheral/matrix/: plib_matrix.c
    ../src/config/sam_a5d2_xult/peripheral/mmu/: plib_mmu.c
    ../src/config/sam_a5d2_xult/peripheral/pio/: plib_pio.c
    ../src/config/sam_a5d2_xult/peripheral/pit/: plib_pit.c
    ../src/config/sam_a5d2_xult/peripheral/spi/: plib_spi1.c
    ../src/config/sam_a5d2_xult/system/cache/: sys_cache.c
    ../src/config/sam_a5d2_xult/system/dma/: sys_dma.c
    ../src/config/sam_a5d2_xult/system/int/src/: sys_int.c
