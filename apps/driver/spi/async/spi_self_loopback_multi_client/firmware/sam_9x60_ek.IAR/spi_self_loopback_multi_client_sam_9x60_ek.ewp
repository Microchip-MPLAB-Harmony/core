# IAR project spi_self_loopback_multi_client_sam_9x60_ek.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM9X60 Microchip SAM9X60
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\src; ..\src\config\sam_9x60_ek; ..\src\packs\SAM9X60_DFP; ..\src\packs\CMSIS\CMSIS\Core\Include; ..\src\packs\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: sam_9x60_ek.out
  ILINK.IlinkIcfFile: ..\src\config\sam_9x60_ek\ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files
    ../src/config/sam_9x60_ek/osal/: osal.h osal_definitions.h osal_impl_basic.h
    ../src/: app_client1.h app_client2.h app_monitor.h
  group Harmony3/Header Files/config/sam_9x60_ek
    ../src/config/sam_9x60_ek/: device_cache.h toolchain_specifics.h definitions.h user.h configuration.h
  group Harmony3/Header Files/config/sam_9x60_ek/bsp
    ../src/config/sam_9x60_ek/bsp/: bsp.h
  group Harmony3/Header Files/config/sam_9x60_ek/peripheral/mmu
    ../src/config/sam_9x60_ek/peripheral/mmu/: plib_mmu.h cp15.h
  group Harmony3/Header Files/config/sam_9x60_ek/peripheral/clk
    ../src/config/sam_9x60_ek/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/sam_9x60_ek/peripheral/pio
    ../src/config/sam_9x60_ek/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/sam_9x60_ek/peripheral/aic
    ../src/config/sam_9x60_ek/peripheral/aic/: plib_aic.h
  group Harmony3/Header Files/config/sam_9x60_ek/peripheral/xdmac
    ../src/config/sam_9x60_ek/peripheral/xdmac/: plib_xdmac_common.h plib_xdmac.h
  group Harmony3/Header Files/config/sam_9x60_ek/peripheral/flexcom/spi
    ../src/config/sam_9x60_ek/peripheral/flexcom/spi/: plib_flexcom4_spi.h plib_flexcom_spi_local.h
  group Harmony3/Header Files/config/sam_9x60_ek/driver
    ../src/config/sam_9x60_ek/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/sam_9x60_ek/driver/spi
    ../src/config/sam_9x60_ek/driver/spi/: drv_spi.h drv_spi_definitions.h
  group Harmony3/Header Files/config/sam_9x60_ek/system
    ../src/config/sam_9x60_ek/system/: system.h system_common.h system_module.h
  group Harmony3/Header Files/config/sam_9x60_ek/system/int
    ../src/config/sam_9x60_ek/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/sam_9x60_ek/system/ports
    ../src/config/sam_9x60_ek/system/ports/: sys_ports.h sys_ports_mapping.h
  group Harmony3/Header Files/config/sam_9x60_ek/system/cache
    ../src/config/sam_9x60_ek/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/sam_9x60_ek/system/dma
    ../src/config/sam_9x60_ek/system/dma/: sys_dma.h sys_dma_mapping.h
  group Harmony3/Header Files/config/sam_9x60_ek/system/debug
    ../src/config/sam_9x60_ek/system/debug/: sys_debug.h
  group Harmony3/Header Files/packs/SAM9X60_DFP
    ../src/packs/SAM9X60_DFP/: device.h sam9x60.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/component
    ../src/packs/SAM9X60_DFP/component/: adc.h aes.h aic.h bsc.h can.h classd.h dbgu.h emac.h flexcom.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pio.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc.h tdes.h trng.h udphs.h uhpfs.h uhphs.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/pio
    ../src/packs/SAM9X60_DFP/pio/: sam9x60.h
  group Harmony3/Source Files
    ../src/: main.c app_client1.c app_client2.c app_monitor.c
  group Harmony3/Source Files/config/sam_9x60_ek
    ../src/config/sam_9x60_ek/: initialization.c interrupts.c cstartup.s vectortrap.s tasks.c
  group Harmony3/Source Files/config/sam_9x60_ek/bsp
    ../src/config/sam_9x60_ek/bsp/: bsp.c
  group Harmony3/Source Files/config/sam_9x60_ek/stdio
    ../src/config/sam_9x60_ek/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_9x60_ek/peripheral/mmu
    ../src/config/sam_9x60_ek/peripheral/mmu/: plib_mmu.c
  group Harmony3/Source Files/config/sam_9x60_ek/peripheral/clk
    ../src/config/sam_9x60_ek/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/sam_9x60_ek/peripheral/pio
    ../src/config/sam_9x60_ek/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/sam_9x60_ek/peripheral/aic
    ../src/config/sam_9x60_ek/peripheral/aic/: plib_aic.c
  group Harmony3/Source Files/config/sam_9x60_ek/peripheral/xdmac
    ../src/config/sam_9x60_ek/peripheral/xdmac/: plib_xdmac.c
  group Harmony3/Source Files/config/sam_9x60_ek/peripheral/flexcom/spi
    ../src/config/sam_9x60_ek/peripheral/flexcom/spi/: plib_flexcom4_spi.c
  group Harmony3/Source Files/config/sam_9x60_ek/driver/spi
    ../src/config/sam_9x60_ek/driver/spi/src/: drv_spi.c drv_spi_local.h
  group Harmony3/Source Files/config/sam_9x60_ek/system/int
    ../src/config/sam_9x60_ek/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/sam_9x60_ek/system/cache
    ../src/config/sam_9x60_ek/system/cache/: sys_cache.c
  group Harmony3/Source Files/config/sam_9x60_ek/system/dma
    ../src/config/sam_9x60_ek/system/dma/: sys_dma.c
  group Harmony3/Linker File
    ../src/config/sam_9x60_ek/: ddram.icf
