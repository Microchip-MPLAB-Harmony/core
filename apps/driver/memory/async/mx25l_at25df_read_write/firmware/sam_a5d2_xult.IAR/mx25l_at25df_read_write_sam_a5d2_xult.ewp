# IAR project mx25l_at25df_read_write_sam_a5d2_xult.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Microchip ATSAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: __FPU_PRESENT=1
  ICCARM.CCIncludePath2: ..\src; ..\src\config\sam_a5d2_xult; ..\src\packs\ATSAMA5D27_DFP; ..\src\packs\CMSIS\CMSIS\Core_A\Include; ..\src\packs\CMSIS; ..\src\arm
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: sam_a5d2_xult.out
  ILINK.IlinkIcfFile: ..\src\config\sam_a5d2_xult\ddr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __FPU_PRESENT=1
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files
    ../src/config/sam_a5d2_xult/osal/: osal.h osal_definitions.h osal_impl_basic.h
    ../src/: app_mx25l.h app_at25df.h app_monitor.h
  group Harmony3/Header Files/config/sam_a5d2_xult
    ../src/config/sam_a5d2_xult/: device_cache.h toolchain_specifics.h definitions.h user.h configuration.h
  group Harmony3/Header Files/config/sam_a5d2_xult/driver
    ../src/config/sam_a5d2_xult/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/sam_a5d2_xult/driver/mx25l
    ../src/config/sam_a5d2_xult/driver/mx25l/: drv_mx25l.h drv_mx25l_definitions.h
    ../src/config/sam_a5d2_xult/driver/mx25l/src/: drv_mx25l_local.h
  group Harmony3/Header Files/config/sam_a5d2_xult/driver/memory
    ../src/config/sam_a5d2_xult/driver/memory/src/: drv_memory_local.h
    ../src/config/sam_a5d2_xult/driver/memory/: drv_memory.h drv_memory_definitions.h
  group Harmony3/Header Files/config/sam_a5d2_xult/driver/spi_flash/at25df
    ../src/config/sam_a5d2_xult/driver/spi_flash/at25df/: drv_at25df.h drv_at25df_definitions.h
  group Harmony3/Header Files/config/sam_a5d2_xult/peripheral/pit
    ../src/config/sam_a5d2_xult/peripheral/pit/: plib_pit.h
  group Harmony3/Header Files/config/sam_a5d2_xult/peripheral/mmu
    ../src/config/sam_a5d2_xult/peripheral/mmu/: plib_mmu.h
  group Harmony3/Header Files/config/sam_a5d2_xult/peripheral/matrix
    ../src/config/sam_a5d2_xult/peripheral/matrix/: plib_matrix.h
  group Harmony3/Header Files/config/sam_a5d2_xult/peripheral/l2cc
    ../src/config/sam_a5d2_xult/peripheral/l2cc/: plib_l2cc.h
  group Harmony3/Header Files/config/sam_a5d2_xult/peripheral/clk
    ../src/config/sam_a5d2_xult/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/sam_a5d2_xult/peripheral/pio
    ../src/config/sam_a5d2_xult/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/sam_a5d2_xult/peripheral/aic
    ../src/config/sam_a5d2_xult/peripheral/aic/: plib_aic.h
  group Harmony3/Header Files/config/sam_a5d2_xult/peripheral/tc
    ../src/config/sam_a5d2_xult/peripheral/tc/: plib_tc0.h plib_tc_common.h
  group Harmony3/Header Files/config/sam_a5d2_xult/peripheral/qspi
    ../src/config/sam_a5d2_xult/peripheral/qspi/: plib_qspi_common.h plib_qspi0.h
  group Harmony3/Header Files/config/sam_a5d2_xult/peripheral/spi
    ../src/config/sam_a5d2_xult/peripheral/spi/: plib_spi_common.h plib_spi0.h
  group Harmony3/Header Files/config/sam_a5d2_xult/system
    ../src/config/sam_a5d2_xult/system/: system.h system_common.h system_module.h system_media.h
  group Harmony3/Header Files/config/sam_a5d2_xult/system/time
    ../src/config/sam_a5d2_xult/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_a5d2_xult/system/time/src/: sys_time_local.h
  group Harmony3/Header Files/config/sam_a5d2_xult/system/int
    ../src/config/sam_a5d2_xult/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/sam_a5d2_xult/system/ports
    ../src/config/sam_a5d2_xult/system/ports/: sys_ports.h sys_ports_mapping.h
  group Harmony3/Header Files/config/sam_a5d2_xult/system/cache
    ../src/config/sam_a5d2_xult/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/sam_a5d2_xult/bsp
    ../src/config/sam_a5d2_xult/bsp/: bsp.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP
    ../src/packs/ATSAMA5D27_DFP/: device.h atsama5d27.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/component
    ../src/packs/ATSAMA5D27_DFP/component/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom.h gmac.h i2sc.h icm.h isc.h l2cc.h lcdc.h matrix.h mcan.h mpddrc.h pdmic.h pio.h pit.h pmc.h ptc.h pwm.h qspi.h rstc.h rtc.h rxlp.h sckc.h sdmmc.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi.h ssc.h tc.h tdes.h trng.h twihs.h uart.h udphs.h uhphs.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/pio
    ../src/packs/ATSAMA5D27_DFP/pio/: sama5d27.h
  group Harmony3/Header Files/packs/CMSIS/CMSIS/Core_A/Include
    ../src/packs/CMSIS/CMSIS/Core_A/Include/: cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_cp15.h core_ca.h
  group Harmony3/Source Files
    ../src/: main.c app_mx25l.c app_at25df.c app_monitor.c
  group Harmony3/Source Files/config/sam_a5d2_xult
    ../src/config/sam_a5d2_xult/: initialization.c interrupts.c cstartup.s fault_handlers.c tasks.c
  group Harmony3/Source Files/config/sam_a5d2_xult/driver/mx25l
    ../src/config/sam_a5d2_xult/driver/mx25l/src/: drv_mx25l.c
  group Harmony3/Source Files/config/sam_a5d2_xult/driver/memory
    ../src/config/sam_a5d2_xult/driver/memory/src/: drv_memory.c
  group Harmony3/Source Files/config/sam_a5d2_xult/driver/spi_flash/at25df
    ../src/config/sam_a5d2_xult/driver/spi_flash/at25df/src/: drv_at25df.c drv_at25df_local.h
  group Harmony3/Source Files/config/sam_a5d2_xult/peripheral/pit
    ../src/config/sam_a5d2_xult/peripheral/pit/: plib_pit.c
  group Harmony3/Source Files/config/sam_a5d2_xult/peripheral/mmu
    ../src/config/sam_a5d2_xult/peripheral/mmu/: plib_mmu.c
  group Harmony3/Source Files/config/sam_a5d2_xult/peripheral/matrix
    ../src/config/sam_a5d2_xult/peripheral/matrix/: plib_matrix.c
  group Harmony3/Source Files/config/sam_a5d2_xult/peripheral/l2cc
    ../src/config/sam_a5d2_xult/peripheral/l2cc/: plib_l2cc.c
  group Harmony3/Source Files/config/sam_a5d2_xult/peripheral/clk
    ../src/config/sam_a5d2_xult/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/sam_a5d2_xult/peripheral/pio
    ../src/config/sam_a5d2_xult/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/sam_a5d2_xult/peripheral/aic
    ../src/config/sam_a5d2_xult/peripheral/aic/: plib_aic.c
  group Harmony3/Source Files/config/sam_a5d2_xult/peripheral/tc
    ../src/config/sam_a5d2_xult/peripheral/tc/: plib_tc0.c
  group Harmony3/Source Files/config/sam_a5d2_xult/peripheral/qspi
    ../src/config/sam_a5d2_xult/peripheral/qspi/: plib_qspi0.c
  group Harmony3/Source Files/config/sam_a5d2_xult/peripheral/spi
    ../src/config/sam_a5d2_xult/peripheral/spi/: plib_spi0.c
  group Harmony3/Source Files/config/sam_a5d2_xult/stdio
    ../src/config/sam_a5d2_xult/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_a5d2_xult/system/time
    ../src/config/sam_a5d2_xult/system/time/src/: sys_time.c
  group Harmony3/Source Files/config/sam_a5d2_xult/system/int
    ../src/config/sam_a5d2_xult/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/sam_a5d2_xult/system/cache
    ../src/config/sam_a5d2_xult/system/cache/: sys_cache.c
  group Harmony3/Source Files/config/sam_a5d2_xult/bsp
    ../src/config/sam_a5d2_xult/bsp/: bsp.c
  group Harmony3/Linker File
    ../src/config/sam_a5d2_xult/: ddr.icf
