<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\mx25l_at25df_read_write_sam_a5d2_xult.ewp</path>
    </project>
</workspace>
