<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\at25_eeprom_read_write_sam_9x60_ek.ewp</path>
    </project>
</workspace>
