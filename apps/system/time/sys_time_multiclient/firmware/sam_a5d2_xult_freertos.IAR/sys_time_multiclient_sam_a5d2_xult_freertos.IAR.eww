<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sys_time_multiclient_sam_a5d2_xult_freertos.IAR.ewp</path>
    </project>
    <batchBuild />
</workspace>
