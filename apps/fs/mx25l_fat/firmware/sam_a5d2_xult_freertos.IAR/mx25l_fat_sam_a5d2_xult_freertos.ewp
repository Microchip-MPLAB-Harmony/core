# IAR project mx25l_fat_sam_a5d2_xult_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Microchip ATSAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCIncludePath2: ..\..\firmware\src; ..\..\firmware\src\config\sam_a5d2_xult_freertos; ..\..\firmware\src\packs\ATSAMA5D27_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core_A\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm; ..\..\firmware\src\third_party\rtos\FreeRTOS\Source\portable\IAR\SAM\CA5; ..\..\firmware\src\third_party\rtos\FreeRTOS\Source\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\config\sam_a5d2_xult_freertos; ..\src\third_party\rtos\FreeRTOS\Source\portable\IAR\SAM\CA5
  OBJCOPY.OOCOutputFile: u-boot.bin
  ILINK.IlinkOutputFile: mx25l_fat_sam_a5d2_xult_freertos.out
  ILINK.IlinkIcfFile: ..\..\firmware\src\config\sam_a5d2_xult_freertos\ddr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/config/sam_a5d2_xult_freertos/: sam_a5d2_xult_freertos.ipcf
  group IAR Project Connection File/Header Files
    ../src/packs/ATSAMA5D27_DFP/component/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom.h gmac.h i2sc.h icm.h isc.h l2cc.h lcdc.h matrix.h mcan.h mpddrc.h pdmic.h pio.h pio_ctrl.h pit.h pmc.h ptc.h pwm.h qspi.h rstc.h rtc.h rxlp.h sckc.h sdmmc.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi.h ssc.h tc.h tdes.h trng.h twihs.h uart.h udphs.h uhphs.h wdt.h xdmac.h
    ../src/: app.h
    ../src/packs/CMSIS/CMSIS/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h
    ../src/packs/ATSAMA5D27_DFP/: atsama5d27.h device.h
    ../src/config/sam_a5d2_xult_freertos/bsp/: bsp.h
    ../src/packs/CMSIS/CMSIS/Core_A/Include/: cmsis_compiler.h cmsis_cp15.h cmsis_gcc.h cmsis_iccarm.h core_ca.h
    ../src/config/sam_a5d2_xult_freertos/: configuration.h definitions.h device_cache.h FreeRTOSConfig.h user.h
    ../src/third_party/rtos/FreeRTOS/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
    ../src/config/sam_a5d2_xult_freertos/system/fs/fat_fs/src/hardware_access/: diskio.h
    ../src/config/sam_a5d2_xult_freertos/driver/: driver.h driver_common.h
    ../src/config/sam_a5d2_xult_freertos/driver/memory/: drv_memory.h drv_memory_definitions.h
    ../src/config/sam_a5d2_xult_freertos/driver/memory/src/: drv_memory_local.h
    ../src/config/sam_a5d2_xult_freertos/driver/mx25l/: drv_mx25l.h drv_mx25l_definitions.h
    ../src/config/sam_a5d2_xult_freertos/driver/mx25l/src/: drv_mx25l_local.h
    ../src/config/sam_a5d2_xult_freertos/system/fs/fat_fs/src/file_system/: ff.h ffconf.h
    ../src/config/sam_a5d2_xult_freertos/system/fs/mpfs/: mpfs.h
    ../src/config/sam_a5d2_xult_freertos/system/fs/mpfs/src/: mpfs_local.h
    ../src/config/sam_a5d2_xult_freertos/osal/: osal.h osal_definitions.h osal_freertos.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/aic/: plib_aic.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/clk/: plib_clk.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/l2cc/: plib_l2cc.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/matrix/: plib_matrix.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/mmu/: plib_mmu.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/pio/: plib_pio.h plib_pio_pin.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/pit/: plib_pit.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/qspi/: plib_qspi0.h plib_qspi_common.h
    ../src/config/sam_a5d2_xult_freertos/peripheral/tc/: plib_tc0.h plib_tc_common.h
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/CA5/: portASM.h portmacro.h
    ../src/packs/ATSAMA5D27_DFP/pio/: sama5d27.h
    ../src/config/sam_a5d2_xult_freertos/system/fs/: sys_fs.h sys_fs_media_manager.h
    ../src/config/sam_a5d2_xult_freertos/system/fs/src/: sys_fs_local.h sys_fs_media_manager_local.h
    ../src/config/sam_a5d2_xult_freertos/system/int/: sys_int.h sys_int_mapping.h
    ../src/config/sam_a5d2_xult_freertos/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_a5d2_xult_freertos/system/: system.h system_common.h system_media.h system_module.h
    ../src/arm/: toolchain_specifics.h
  group IAR Project Connection File/Source Files
    ../src/: app.c main.c
    ../src/config/sam_a5d2_xult_freertos/bsp/: bsp.c
    ../src/third_party/rtos/FreeRTOS/Source/: croutine.c event_groups.c FreeRTOS_tasks.c list.c queue.c stream_buffer.c timers.c
    ../src/config/sam_a5d2_xult_freertos/: cstartup.s exceptions.c freertos_hooks.c initialization.c interrupts.c tasks.c vectortrap.s
    ../src/config/sam_a5d2_xult_freertos/system/fs/fat_fs/src/: diskio.c ff.c
    ../src/config/sam_a5d2_xult_freertos/driver/memory/src/: drv_memory.c drv_memory_file_system.c
    ../src/config/sam_a5d2_xult_freertos/driver/mx25l/src/: drv_mx25l.c
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/CA5/: FreeRTOS_tick_config.c port.c portASM.s
    ../src/third_party/rtos/FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../src/config/sam_a5d2_xult_freertos/stdio/: iar_monitor.c
    ../src/config/sam_a5d2_xult_freertos/system/fs/mpfs/src/: mpfs.c
    ../src/config/sam_a5d2_xult_freertos/osal/: osal_freertos.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/aic/: plib_aic.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/clk/: plib_clk.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/l2cc/: plib_l2cc.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/matrix/: plib_matrix.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/mmu/: plib_mmu.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/pio/: plib_pio.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/pit/: plib_pit.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/qspi/: plib_qspi0.c
    ../src/config/sam_a5d2_xult_freertos/peripheral/tc/: plib_tc0.c
    ../src/config/sam_a5d2_xult_freertos/system/fs/src/: sys_fs.c sys_fs_media_manager.c
    ../src/config/sam_a5d2_xult_freertos/system/int/src/: sys_int.c
    ../src/config/sam_a5d2_xult_freertos/system/time/src/: sys_time.c sys_time_local.h
