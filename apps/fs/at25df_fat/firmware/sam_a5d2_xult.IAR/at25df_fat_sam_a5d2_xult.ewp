# IAR project at25df_fat_sam_a5d2_xult.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Microchip ATSAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCIncludePath2: ..\..\firmware\src; ..\..\firmware\src\config\sam_a5d2_xult; ..\..\firmware\src\packs\ATSAMA5D27_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core_A\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: u-boot.bin
  ILINK.IlinkOutputFile: at25df_fat_sam_a5d2_xult.out
  ILINK.IlinkIcfFile: ..\..\firmware\src\config\sam_a5d2_xult\ddr.icf
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/config/sam_a5d2_xult/: sam_a5d2_xult.ipcf
  group IAR Project Connection File/Header Files
    ../src/packs/ATSAMA5D27_DFP/component/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom.h gmac.h i2sc.h icm.h isc.h l2cc.h lcdc.h matrix.h mcan.h mpddrc.h pdmic.h pio.h pio_ctrl.h pit.h pmc.h ptc.h pwm.h qspi.h rstc.h rtc.h rxlp.h sckc.h sdmmc.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi.h ssc.h tc.h tdes.h trng.h twihs.h uart.h udphs.h uhphs.h wdt.h xdmac.h
    ../src/: app.h
    ../src/packs/CMSIS/CMSIS/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h
    ../src/packs/ATSAMA5D27_DFP/: atsama5d27.h device.h
    ../src/config/sam_a5d2_xult/bsp/: bsp.h
    ../src/packs/CMSIS/CMSIS/Core_A/Include/: cmsis_compiler.h cmsis_cp15.h cmsis_gcc.h cmsis_iccarm.h core_ca.h
    ../src/config/sam_a5d2_xult/: configuration.h definitions.h device_cache.h user.h
    ../src/config/sam_a5d2_xult/system/fs/fat_fs/src/hardware_access/: diskio.h
    ../src/config/sam_a5d2_xult/driver/: driver.h driver_common.h
    ../src/config/sam_a5d2_xult/driver/spi_flash/at25df/: drv_at25df.h drv_at25df_definitions.h
    ../src/config/sam_a5d2_xult/driver/memory/: drv_memory.h drv_memory_definitions.h
    ../src/config/sam_a5d2_xult/driver/memory/src/: drv_memory_local.h
    ../src/config/sam_a5d2_xult/system/fs/fat_fs/src/file_system/: ff.h ffconf.h
    ../src/config/sam_a5d2_xult/system/fs/mpfs/: mpfs.h
    ../src/config/sam_a5d2_xult/system/fs/mpfs/src/: mpfs_local.h
    ../src/config/sam_a5d2_xult/osal/: osal.h osal_definitions.h osal_impl_basic.h
    ../src/config/sam_a5d2_xult/peripheral/aic/: plib_aic.h
    ../src/config/sam_a5d2_xult/peripheral/clk/: plib_clk.h
    ../src/config/sam_a5d2_xult/peripheral/l2cc/: plib_l2cc.h
    ../src/config/sam_a5d2_xult/peripheral/matrix/: plib_matrix.h
    ../src/config/sam_a5d2_xult/peripheral/mmu/: plib_mmu.h
    ../src/config/sam_a5d2_xult/peripheral/pio/: plib_pio.h plib_pio_pin.h
    ../src/config/sam_a5d2_xult/peripheral/spi/: plib_spi0.h plib_spi_common.h
    ../src/packs/ATSAMA5D27_DFP/pio/: sama5d27.h
    ../src/config/sam_a5d2_xult/system/fs/: sys_fs.h sys_fs_media_manager.h
    ../src/config/sam_a5d2_xult/system/fs/src/: sys_fs_local.h sys_fs_media_manager_local.h
    ../src/config/sam_a5d2_xult/system/int/: sys_int.h sys_int_mapping.h
    ../src/config/sam_a5d2_xult/system/ports/: sys_ports.h sys_ports_mapping.h
    ../src/config/sam_a5d2_xult/system/: system.h system_common.h system_media.h system_module.h
    ../src/arm/: toolchain_specifics.h
  group IAR Project Connection File/Source Files
    ../src/: app.c main.c
    ../src/config/sam_a5d2_xult/bsp/: bsp.c
    ../src/config/sam_a5d2_xult/: cstartup.s exceptions.c initialization.c interrupts.c tasks.c vectortrap.s
    ../src/config/sam_a5d2_xult/system/fs/fat_fs/src/: diskio.c ff.c
    ../src/config/sam_a5d2_xult/driver/spi_flash/at25df/src/: drv_at25df.c drv_at25df_local.h
    ../src/config/sam_a5d2_xult/driver/memory/src/: drv_memory.c drv_memory_file_system.c
    ../src/config/sam_a5d2_xult/stdio/: iar_monitor.c
    ../src/config/sam_a5d2_xult/system/fs/mpfs/src/: mpfs.c
    ../src/config/sam_a5d2_xult/peripheral/aic/: plib_aic.c
    ../src/config/sam_a5d2_xult/peripheral/clk/: plib_clk.c
    ../src/config/sam_a5d2_xult/peripheral/l2cc/: plib_l2cc.c
    ../src/config/sam_a5d2_xult/peripheral/matrix/: plib_matrix.c
    ../src/config/sam_a5d2_xult/peripheral/mmu/: plib_mmu.c
    ../src/config/sam_a5d2_xult/peripheral/pio/: plib_pio.c
    ../src/config/sam_a5d2_xult/peripheral/spi/: plib_spi0.c
    ../src/config/sam_a5d2_xult/system/fs/src/: sys_fs.c sys_fs_media_manager.c
    ../src/config/sam_a5d2_xult/system/int/src/: sys_int.c
