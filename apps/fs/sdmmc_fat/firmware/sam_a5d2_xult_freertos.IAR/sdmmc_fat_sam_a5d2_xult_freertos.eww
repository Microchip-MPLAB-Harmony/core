<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\sdmmc_fat_sam_a5d2_xult_freertos.ewp</path>
    </project>
</workspace>
