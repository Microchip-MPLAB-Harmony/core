<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sdmmc_fat_sam_9x60_ek_freertos.ewp</path>
    </project>
    <batchBuild />
</workspace>
