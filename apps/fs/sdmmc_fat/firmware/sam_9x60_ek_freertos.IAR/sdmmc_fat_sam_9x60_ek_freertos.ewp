# IAR project sdmmc_fat_sam_9x60_ek_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM9X60 Microchip SAM9X60
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCIncludePath2: .; ..\src\config\sam_9x60_ek_freertos\system\fs\fat_fs\file_system; ..\src\config\sam_9x60_ek_freertos\system\fs\fat_fs\hardware_access; ..\src; ..\src\config\sam_9x60_ek_freertos; ..\src\packs\SAM9X60_DFP; ..\src\packs\CMSIS\CMSIS\Core\Include; ..\src\packs\CMSIS; ..\src\arm; ..\src\third_party\rtos\FreeRTOS\Source\portable\IAR\SAM\ARM926; ..\src\third_party\rtos\FreeRTOS\Source\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: sam_9x60_ek_freertos.out
  ILINK.IlinkIcfFile: ..\src\config\sam_9x60_ek_freertos\ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files
    ../src/config/sam_9x60_ek_freertos/osal/: osal.h osal_definitions.h osal_freertos.h
    ../src/: app.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos
    ../src/config/sam_9x60_ek_freertos/: device_cache.h toolchain_specifics.h definitions.h FreeRTOSConfig.h user.h configuration.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/bsp
    ../src/config/sam_9x60_ek_freertos/bsp/: bsp.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/driver
    ../src/config/sam_9x60_ek_freertos/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/driver/sdmmc
    ../src/config/sam_9x60_ek_freertos/driver/sdmmc/: drv_sdmmc.h drv_sdmmc_definitions.h
    ../src/config/sam_9x60_ek_freertos/driver/sdmmc/src/: drv_sdmmc_local.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/system
    ../src/config/sam_9x60_ek_freertos/system/: system.h system_common.h system_module.h system_media.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/system/fs
    ../src/config/sam_9x60_ek_freertos/system/fs/: sys_fs.h sys_fs_media_manager.h sys_fs_fat_interface.h
    ../src/config/sam_9x60_ek_freertos/system/fs/src/: sys_fs_local.h sys_fs_media_manager_local.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/system/fs/fat_fs/file_system
    ../src/config/sam_9x60_ek_freertos/system/fs/fat_fs/file_system/: ff.h ffconf.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/system/fs/fat_fs/hardware_access
    ../src/config/sam_9x60_ek_freertos/system/fs/fat_fs/hardware_access/: diskio.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/system/int
    ../src/config/sam_9x60_ek_freertos/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/system/cache
    ../src/config/sam_9x60_ek_freertos/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/system/time
    ../src/config/sam_9x60_ek_freertos/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_9x60_ek_freertos/system/time/src/: sys_time_local.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/peripheral/pit
    ../src/config/sam_9x60_ek_freertos/peripheral/pit/: plib_pit.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/peripheral/mmu
    ../src/config/sam_9x60_ek_freertos/peripheral/mmu/: plib_mmu.h cp15.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/peripheral/clk
    ../src/config/sam_9x60_ek_freertos/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/peripheral/pio
    ../src/config/sam_9x60_ek_freertos/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/peripheral/aic
    ../src/config/sam_9x60_ek_freertos/peripheral/aic/: plib_aic.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/peripheral/sdmmc
    ../src/config/sam_9x60_ek_freertos/peripheral/sdmmc/: plib_sdmmc_common.h plib_sdmmc0.h
  group Harmony3/Header Files/config/sam_9x60_ek_freertos/peripheral/tc
    ../src/config/sam_9x60_ek_freertos/peripheral/tc/: plib_tc0.h plib_tc_common.h
  group Harmony3/Header Files/packs/SAM9X60_DFP
    ../src/packs/SAM9X60_DFP/: device.h sam9x60.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/component
    ../src/packs/SAM9X60_DFP/component/: adc.h aes.h aic.h bsc.h can.h classd.h dbgu.h emac.h flexcom.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pio.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc.h tdes.h trng.h udphs.h uhpfs.h uhphs.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/pio
    ../src/packs/SAM9X60_DFP/pio/: sam9x60.h
  group Harmony3/Header Files/FreeRTOS/Source/include
    ../src/third_party/rtos/FreeRTOS/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h deprecated_definitions.h task.h timers.h mpu_prototypes.h stream_buffer.h message_buffer.h
  group Harmony3/Header Files/FreeRTOS/Source/portable/IAR/SAM/ARM926
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/ARM926/: portmacro.h
  group Harmony3/Source Files
    ../src/: main.c app.c
    ../src/config/sam_9x60_ek_freertos/osal/: osal_freertos.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos
    ../src/config/sam_9x60_ek_freertos/: initialization.c interrupts.c cstartup.s vectortrap.s freertos_hooks.c tasks.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/bsp
    ../src/config/sam_9x60_ek_freertos/bsp/: bsp.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/driver/sdmmc
    ../src/config/sam_9x60_ek_freertos/driver/sdmmc/src/: drv_sdmmc_file_system.c drv_sdmmc.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/system/fs
    ../src/config/sam_9x60_ek_freertos/system/fs/src/: sys_fs.c sys_fs_media_manager.c sys_fs_fat_interface.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/system/fs/fat_fs/file_system
    ../src/config/sam_9x60_ek_freertos/system/fs/fat_fs/file_system/: ff.c ffunicode.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/system/fs/fat_fs/hardware_access
    ../src/config/sam_9x60_ek_freertos/system/fs/fat_fs/hardware_access/: diskio.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/system/int
    ../src/config/sam_9x60_ek_freertos/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/system/cache
    ../src/config/sam_9x60_ek_freertos/system/cache/: sys_cache.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/system/time
    ../src/config/sam_9x60_ek_freertos/system/time/src/: sys_time.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/peripheral/pit
    ../src/config/sam_9x60_ek_freertos/peripheral/pit/: plib_pit.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/peripheral/mmu
    ../src/config/sam_9x60_ek_freertos/peripheral/mmu/: plib_mmu.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/peripheral/clk
    ../src/config/sam_9x60_ek_freertos/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/peripheral/pio
    ../src/config/sam_9x60_ek_freertos/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/peripheral/aic
    ../src/config/sam_9x60_ek_freertos/peripheral/aic/: plib_aic.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/peripheral/sdmmc
    ../src/config/sam_9x60_ek_freertos/peripheral/sdmmc/: plib_sdmmc0.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/peripheral/tc
    ../src/config/sam_9x60_ek_freertos/peripheral/tc/: plib_tc0.c
  group Harmony3/Source Files/config/sam_9x60_ek_freertos/stdio
    ../src/config/sam_9x60_ek_freertos/stdio/: iar_monitor.c
  group Harmony3/Source Files/FreeRTOS/Source
    ../src/third_party/rtos/FreeRTOS/Source/: croutine.c list.c queue.c FreeRTOS_tasks.c timers.c event_groups.c stream_buffer.c
  group Harmony3/Source Files/FreeRTOS/Source/portable/MemMang
    ../src/third_party/rtos/FreeRTOS/Source/portable/MemMang/: heap_1.c
  group Harmony3/Source Files/FreeRTOS/Source/portable/IAR/SAM/ARM926
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/ARM926/: port.c portASM.s FreeRTOS_tick_config.c
  group Harmony3/Linker File
    ../src/config/sam_9x60_ek_freertos/: ddram.icf
